<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\embedded_course_example_1_led_blink.ewp</path>
  </project>
  <batchBuild />
</workspace>
